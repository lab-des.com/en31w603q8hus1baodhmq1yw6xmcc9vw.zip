Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-12-21T08:53:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 21 08:53:17 2018 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{2993B325-DA2F-4815-9415-E8413FBD897D}\ifc * Database version: 5507 * Database creation date: Fri Dec 21 08:53:17 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 21 08:53:17 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 21 08:53:17 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: NesTable, CONV_Vitra_Tbls_NesTable:NesTable:453240
In: Level 1
Material: 52 soft light, 01 chrome
Pset_ManufacturerTypeInformation - ModelReference: 86013015; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - AngleControl: 90 deg; HeightControl: 770 mm; HeightDimension: 770 mm; TableTiltAngle: 0 deg
Dimensions - Area: 0.8295 m2; Volume: 0.13475 m3
Materials and Finishes - TableMainMaterial: 52 soft light
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_Tbls_NesTable: NesTable; Family and Type: CONV_Vitra_Tbls_NesTable: NesTable; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_Tbls_NesTable: NesTable; Type Id: CONV_Vitra_Tbls_NesTable: NesTable; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_Tbls_NesTable; ConvergoRefNr: 0089-1812-0160-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Tables; NBSReference: 45-35-86/327; ProductInformation: NesTable is the ideal solution when working from home in a sofa or armchair: the height and angle of the tray platform are fully adjustable and the shape of the base allows users to draw it up close to most types of seating.; Revision: n/a; Uniclass2: Pr_40_50_21_58; Uniclass2015Description: Occasional tables; Uniclass2015Reference: Pr_40_50_21_58; Version: 1; VersionDate: 20/12/2018
Identity Data(Type) - Collection: NesTable; Cost: 0; Description: Thanks to technological innovations, it is possible to work on a laptop computer virtually anywhere today – yet suitable furniture is often lacking. NesTable is the ideal solution when working from home in a sofa or armchair: the height and angle of the tray platform are fully adjustable and the shape of the base allows users to draw it up close to most types of seating.; Designer: Jasper Morrison; Manufacturer: Vitra; Model: NesTable; OmniClass Number: 23.40.20.14.17.24; OmniClass Title: Coffee Tables; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/984034/storage/master/download/FS_NesTable-EN_Preview-Single-Page.pdf; Type Name: NesTable; URL: https://www.vitra.com/en-un/living/product/details/nestable
Materials and Finishes(Type) - TableSecondaryMaterial: 01 chrome
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_Tbls_NesTable; Features: Height adjustable. Adjustable table angle.; Finish: Tray: polyurethane. Column: steel, powder-coated textured finish. Extension bar: steel, polished chrome finish. Base: die-cast aluminium, powder-coated textured finish.; Grade: n/a; Material: Polyurethane & steel; ModelNumber: n/a; ModelReference: 86013015; Name: Tbls_NesTable; ReplacementCost: n/a; Shape: Sculptured; Size: 500x350x574/770 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
